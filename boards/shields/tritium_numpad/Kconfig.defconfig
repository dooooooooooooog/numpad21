## boards/shields/tritium_numpad/Kconfig.shield
```kconfig
config SHIELD_TRITIUM_NUMPAD
    def_bool $(shields_list_contains,tritium_numpad)
```
